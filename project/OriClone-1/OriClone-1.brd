# Repository JennyDigital/OriClone-1

File README.md:

# OriClone-1
A New Oric!

The Oric-1 and Atmos line of computers are something I loved as a kid, and I thought it about time there was a new one in my collection.

So I'm working on it, and sharing with the world.  As always, have fun!

Please note that the W65C22S version of the VIA IC won't let the cassette port read tapes, I have no idea why yet.  In that case use the Rockwell version instead, or alternatively, use something like an Erebus or disk interface.

Regards,

JennyDigital.

## EAGLE design project/OriClone-1/OriClone-1.brd

Parts:
C1: 120pF; C050-025X075
C21: 100nF; C050-025X075
IC1: IC1; HCS10017_DIP
IC2: 74F04N; DIL14
IC3, IC4: 74LS257N; DIL16
Q1: 12MHz; HC49U-V
R1, R2: 1K; 0207/2V
R3: 220R; 0207/2V
R4: 560; 0207/2V
R35: 2K2; 0207/10

Connections:
!CAS: IC2.12 (O); also elsewhere on the board
!CSROM: IC1.!CSROM; also elsewhere on the board
!MAP: IC1.!MAP; also elsewhere on the board
!PHI2: IC2.6 (O); also elsewhere on the board
!R/!W_RAM: IC1.!R/!W_RAM (!R!/W_RAM), IC2.11 (I)
!RAS: IC2.8 (O); also elsewhere on the board
!VIA_CS: IC1.!VIA_CS; also elsewhere on the board
+5V: C21.1, IC1.VCC, IC2.14 (VCC), IC3.16 (VCC), IC4.16 (VCC), R4.2; also elsewhere on the board
A0: IC3.6 (2B); also elsewhere on the board
A1: IC3.3 (1B); also elsewhere on the board
A2: IC4.6 (2B); also elsewhere on the board
A3: IC4.3 (1B); also elsewhere on the board
A4: IC3.13 (4B); also elsewhere on the board
A5: IC3.10 (3B); also elsewhere on the board
A6: IC4.10 (3B); also elsewhere on the board
A7: IC4.13 (4B); also elsewhere on the board
A8: IC1.A8; also elsewhere on the board
A9: IC1.A9; also elsewhere on the board
A10: IC1.A10; also elsewhere on the board
A11: IC1.A11; also elsewhere on the board
A12: IC1.A12; also elsewhere on the board
A13: IC1.A13; also elsewhere on the board
A14: IC1.A14; also elsewhere on the board
A15: IC1.A15; also elsewhere on the board
CAS: IC1.CAS, IC2.13 (I)
CLK: IC1.CLK, R3.1, R4.1
D0: IC1.D0; also elsewhere on the board
D1: IC1.D1; also elsewhere on the board
D2: IC1.D2; also elsewhere on the board
D3: IC1.D3; also elsewhere on the board
D4: IC1.D4; also elsewhere on the board
D5: IC1.D5; also elsewhere on the board
D6: IC1.D6; also elsewhere on the board
D7: IC1.D7; also elsewhere on the board
GND: C21.2, IC1.VSS, IC2.7 (GND), IC3.8 (GND), IC3.15 (G), IC4.8 (GND), IC4.15 (G), R35.2; also elsewhere on the board
MA0: IC3.7 (2Y); also elsewhere on the board
MA1: IC3.4 (1Y); also elsewhere on the board
MA2: IC4.7 (2Y); also elsewhere on the board
MA3: IC4.4 (1Y); also elsewhere on the board
MA4: IC3.12 (4Y); also elsewhere on the board
MA5: IC3.9 (3Y); also elsewhere on the board
MA6: IC4.9 (3Y); also elsewhere on the board
MA7: IC4.12 (4Y); also elsewhere on the board
MPX: IC1.MPX, IC3.1 (!A!/B), IC4.1 (!A!/B)
unnamed: C1.1, IC2.2 (O), R1.2
unnamed: C1.2, IC2.3 (I), R2.1
unnamed: IC2.4 (O), Q1.2, R2.2, R3.2
unnamed: IC2.1 (I), Q1.1, R1.1
PHI0: IC1.PHI0; also elsewhere on the board
PHI2: IC2.5 (I); also elsewhere on the board
R/!W: IC1.R/!W; also elsewhere on the board
R/!W_RAM: IC2.10 (O); also elsewhere on the board
RAS: IC1.RAS, IC2.9 (I)
ULA_A0: IC1.ULA_A0, IC3.5 (2A)
ULA_A1: IC1.ULA_A1, IC3.2 (1A)
ULA_A2: IC1.ULA_A2, IC4.5 (2A)
ULA_A3: IC1.ULA_A3, IC4.2 (1A)
ULA_A4: IC1.ULA_A4, IC3.14 (4A)
ULA_A5: IC1.ULA_A5, IC3.11 (3A)
ULA_A6: IC1.ULA_A6, IC4.11 (3A)
ULA_A7: IC1.ULA_A7, IC4.14 (4A)
ULA_BLUE: IC1.BLUE; also elsewhere on the board
ULA_CSYNC: IC1.CSYNC; also elsewhere on the board
ULA_GREEN: IC1.GREEN; also elsewhere on the board
ULA_RED: IC1.RED, R35.1; also elsewhere on the board

Notes on the sheet:
Decoupling

Parts:
C6: 10nF; C050-025X075
C7: 2.2uF; E5-6
IC15: AY-3-8912; DIP
JP1: PINHD-1X14; 1X14
R6: 47K; 0207/2V
R7: 47K; 0207/10
R21: 470R; 0207/10
R22: 1K; 0207/10
R23: 4K7; 0207/10
T2: 2N3904; TO92

Connections:
!RESET: IC15.!RESET; also elsewhere on the board
+5V: IC15.BC2, IC15.VCC, JP1.14, R6.2; also elsewhere on the board
CA2: IC15.BC1; also elsewhere on the board
CB2: IC15.BDIR; also elsewhere on the board
GND: C6.2, IC15.VSS, JP1.10, R21.2, R22.2, T2.3 (E); also elsewhere on the board
KBD_COL0: IC15.IOA0, JP1.1
KBD_COL1: IC15.IOA1, JP1.2
KBD_COL2: IC15.IOA2, JP1.3
KBD_COL3: IC15.IOA3, JP1.4
KBD_COL4: IC15.IOA4, JP1.12
KBD_COL5: IC15.IOA5, JP1.11
KBD_COL6: IC15.IOA6, JP1.9
KBD_COL7: IC15.IOA7, JP1.5
KB_INT: JP1.13, R6.1, R7.2
unnamed: R7.1, T2.2 (B)
unnamed: C6.1, C7.+, R21.1, R23.1
unnamed: IC15.CH_A, IC15.CH_B, IC15.CH_C, R22.1, R23.2
PA0: IC15.DA0; also elsewhere on the board
PA1: IC15.DA1; also elsewhere on the board
PA2: IC15.DA2; also elsewhere on the board
PA3: IC15.DA3; also elsewhere on the board
PA4: IC15.DA4; also elsewhere on the board
PA5: IC15.DA5; also elsewhere on the board
PA6: IC15.DA6; also elsewhere on the board
PA7: IC15.DA7; also elsewhere on the board
PB0: JP1.8; also elsewhere on the board
PB1: JP1.7; also elsewhere on the board
PB2: JP1.6; also elsewhere on the board
PB3: T2.1 (C); also elsewhere on the board
PHI1: IC15.CLOCK; also elsewhere on the board
SOUND_OUT: C7.-; also elsewhere on the board

Notes on the sheet:
KBD_R0WA0
KBD_R0WA1
KBD_R0WA2
Low ESR or Tant only.
Note: No amplifier is provided. Sound must be taken from either the video port or the cassette port.

Parts:
C17, C18, C19, C20: 100nF; C050-025X075
IC5, IC6: TMS4464_DIP18; DIP18
IC7: 28C256_DIP; DIP28_WIDE
IC8: 74LS00N; DIL14
JP2: PINHD-1X3; 1X03
R5, R8: 2K2; 0207/10

Connections:
!CAS: IC5.!CAS, IC6.!CAS; also elsewhere on the board
!CSROM: IC8.1 (I0), IC8.2 (I1); also elsewhere on the board
!CS_INTROM: IC7.!CE, IC8.6 (O)
!PHI2: IC7.!OE; also elsewhere on the board
!RAS: IC5.!RAS, IC6.!RAS; also elsewhere on the board
!ROMDIS: IC8.4 (I0), R8.1; also elsewhere on the board
+5V: C17.1, C18.1, C19.1, C20.1, IC5.VDD, IC6.VDD, IC7.!WE, IC7.VCC, IC8.12 (I0), IC8.13 (I1), IC8.14 (VCC), JP2.1, R8.2; also elsewhere on the board
A0: IC7.A0; also elsewhere on the board
A1: IC7.A1; also elsewhere on the board
A2: IC7.A2; also elsewhere on the board
A3: IC7.A3; also elsewhere on the board
A4: IC7.A4; also elsewhere on the board
A5: IC7.A5; also elsewhere on the board
A6: IC7.A6; also elsewhere on the board
A7: IC7.A7; also elsewhere on the board
A8: IC7.A8; also elsewhere on the board
A9: IC7.A9; also elsewhere on the board
A10: IC7.A10; also elsewhere on the board
A11: IC7.A11; also elsewhere on the board
A12: IC7.A12; also elsewhere on the board
A13: IC7.A13; also elsewhere on the board
BANKSEL: IC7.A14, R5.2
CSROM: IC8.3 (O), IC8.5 (I1)
D0: IC5.DQ1, IC7.I/O0; also elsewhere on the board
D1: IC5.DQ2, IC7.I/O1; also elsewhere on the board
D2: IC5.DQ3, IC7.I/O2; also elsewhere on the board
D3: IC5.DQ4, IC7.I/O3; also elsewhere on the board
D4: IC6.DQ1, IC7.I/O4; also elsewhere on the board
D5: IC6.DQ2, IC7.I/O5; also elsewhere on the board
D6: IC6.DQ3, IC7.I/O6; also elsewhere on the board
D7: IC6.DQ4, IC7.I/O7; also elsewhere on the board
GND: C17.2, C18.2, C19.2, C20.2, IC5.!G, IC5.VSS, IC6.!G, IC6.VSS, IC7.GND, IC8.7 (GND), JP2.3; also elsewhere on the board
MA0: IC5.A0, IC6.A0; also elsewhere on the board
MA1: IC5.A1, IC6.A1; also elsewhere on the board
MA2: IC5.A2, IC6.A2; also elsewhere on the board
MA3: IC5.A3, IC6.A3; also elsewhere on the board
MA4: IC5.A4, IC6.A4; also elsewhere on the board
MA5: IC5.A5, IC6.A5; also elsewhere on the board
MA6: IC5.A6, IC6.A6; also elsewhere on the board
MA7: IC5.A7, IC6.A7; also elsewhere on the board
unnamed: JP2.2, R5.1
unnamed: IC8.9 (I0), IC8.10 (I1), IC8.11 (O)
R/!W_RAM: IC5.!W, IC6.!W; also elsewhere on the board

Notes on the sheet:
ROM Gating
Atmos/Oric-1 ROM Image Selection
Decoupling

Parts:
C2, C4: 47nF; C050-025X075
C3, C22: 100nF; C050-025X075
C5: 2.2nF; C050-025X075
D1, D2, D3: DIODEDO-1N4148; DO-1N4148
IC14: LM358; DIP08
K1: 351
R9: 220R; 0207/10
R10, R11: 22K; 0207/10
R12, R20: 1K; 0207/10
R13: 10K; 0207/2V
R14: 10K; 0207/7
R15: 12K; 0207/10
R16, R17, R19: 10K; 0207/10
R18: 100K; 0207/10
T3, T5: 2N3904; TO92
X1: MAB7SH

Connections:
+5V: C22.2, D1.C, IC14.8 (V+), K1.1, R13.2, R20.2; also elsewhere on the board
CB1: C5.2, R20.1, T5.1 (C); also elsewhere on the board
GND: C2.1, C3.1, C5.1, C22.1, IC14.4 (V-), R11.1, R14.1, T3.3 (E), T5.3 (E), X1.2; also elsewhere on the board
unnamed: D1.A, K1.16 (2), T3.1 (C)
unnamed: IC14.5 (+IN), R12.2, R18.1
unnamed: R9.1, T3.2 (B)
unnamed: K1.S2 (S), X1.6
unnamed: K1.P2, X1.7
unnamed: IC14.1 (OUT), R12.1, R16.2
unnamed: R15.2, R16.1
unnamed: C4.1, R17.1
unnamed: IC14.7 (OUT), R18.2, R19.1
unnamed: D2.C, D3.A, IC14.2 (-IN), R15.1, R17.2
unnamed: C3.2, D2.A, D3.C, IC14.3 (+IN), IC14.6 (-IN), R13.1, R14.2
unnamed: R19.2, T5.2 (B)
PB6: R9.2; also elsewhere on the board
PB7: R10.2; also elsewhere on the board
PE: X1.PE, X1.PE@ (PE)
SOUND_OUT: X1.4, X1.5; also elsewhere on the board
TAPE_IN: C4.2, X1.3
TAPE_OUT: C2.2, R10.1, R11.2, X1.1

Notes on the sheet:
Note: Using a W65C22S variant may require changing R20 to 270R. This is because of bus holding circuitry in the WDC part.

Parts:
C8, C16: 100nF; C050-025X075
IC9: 74LS365N; DIL16
R24, R25, R26, R27: 220R; 0207/10
SK1: LUMBERG_DIN_0105_08-1; 0105-08-1

Connections:
+5V: C8.1, C16.1, IC9.16 (VCC), SK1.8; also elsewhere on the board
BUF_BLUE: IC9.3 (Y1), R24.1
BUF_CSYNC: IC9.13 (Y6), R27.1
BUF_GREEN: IC9.11 (Y5), R26.1
BUF_RED: IC9.9 (Y4), R25.1
GND: C8.2, C16.2, IC9.1 (G1), IC9.8 (GND), IC9.15 (G2), SK1.3; also elsewhere on the board
OUT_BLUE: R24.2, SK1.5
OUT_CSYNC: R27.2, SK1.4
OUT_GREEN: R26.2, SK1.2
OUT_RED: R25.2, SK1.1
SOUND_OUT: SK1.7; also elsewhere on the board
ULA_BLUE: IC9.2 (A1); also elsewhere on the board
ULA_CSYNC: IC9.14 (A6); also elsewhere on the board
ULA_GREEN: IC9.12 (A5); also elsewhere on the board
ULA_RED: IC9.10 (A4); also elsewhere on the board

Notes on the sheet:
No PAL generation. RGB only this time.
Decoupling

Parts:
C9: 2.2nF; C050-025X075
C14, C15: 100nF; C050-025X075
D5: BAT85; DO34-7
IC10: 6522A; DIP
IC11: SY or R6502A; DIL40
R28, R29, R30: 2K2; 0207/10
R36: 100K; 0207/10
S1: TAC_SWITCHPTH; TACTILE-PTH
SV1: ML20L
SV2: ML34L

Connections:
!IRQ: D5.A, IC11.4 (#IRQ), R30.1, SV2.8
!MAP: R29.1, SV2.1; also elsewhere on the board
!NMI: IC11.6 (NMI), R36.1, S1.1
!RESET: IC10.RESB, IC11.40 (RST), SV2.4; also elsewhere on the board
!ROMDIS: SV2.2; also elsewhere on the board
!VIA_CS: IC10.CS2B, SV2.5; also elsewhere on the board
+5V: C14.1, C15.1, IC10.VDD, IC11.2 (RDY), IC11.8 (VCC), IC11.38 (#SO), R28.2, R29.2, R30.2, R36.2, SV2.33; also elsewhere on the board
A0: IC10.RS0, IC11.9 (A0), SV2.13; also elsewhere on the board
A1: IC10.RS1, IC11.10 (A1), SV2.15; also elsewhere on the board
A2: IC10.RS2, IC11.11 (A2), SV2.17; also elsewhere on the board
A3: IC10.RS3, IC11.12 (A3), SV2.11; also elsewhere on the board
A4: IC11.13 (A4), SV2.20; also elsewhere on the board
A5: IC11.14 (A5), SV2.21; also elsewhere on the board
A6: IC11.15 (A6), SV2.23; also elsewhere on the board
A7: IC11.16 (A7), SV2.25; also elsewhere on the board
A8: IC11.17 (A8), SV2.27; also elsewhere on the board
A9: IC11.18 (A9), SV2.29; also elsewhere on the board
A10: IC11.19 (A10), SV2.31; also elsewhere on the board
A11: IC11.20 (A11), SV2.32; also elsewhere on the board
A12: IC11.22 (A12), SV2.30; also elsewhere on the board
A13: IC11.23 (A13), SV2.28; also elsewhere on the board
A14: IC11.24 (A14), SV2.26; also elsewhere on the board
A15: IC11.25 (A15), SV2.24; also elsewhere on the board
CA1: IC10.CA1, SV1.19
CA2: IC10.CA2; also elsewhere on the board
CB1: IC10.CB1; also elsewhere on the board
CB2: IC10.CB2; also elsewhere on the board
D0: IC10.D0, IC11.33 (D0), SV2.10; also elsewhere on the board
D1: IC10.D1, IC11.32 (D1), SV2.12; also elsewhere on the board
D2: IC10.D2, IC11.31 (D2), SV2.9; also elsewhere on the board
D3: IC10.D3, IC11.30 (D3), SV2.16; also elsewhere on the board
D4: IC10.D4, IC11.29 (D4), SV2.18; also elsewhere on the board
D5: IC10.D5, IC11.28 (D5), SV2.19; also elsewhere on the board
D6: IC10.D6, IC11.27 (D6), SV2.14; also elsewhere on the board
D7: IC10.D7, IC11.26 (D7), SV2.22; also elsewhere on the board
GND: C9.2, C14.2, C15.2, IC10.VSS, IC11.1 (VSS), S1.4, SV1.2, SV1.4, SV1.6, SV1.8, SV1.10, SV1.12, SV1.14, SV1.16, SV1.18, SV1.20, SV2.34; also elsewhere on the board
I/O_CONTROL: C9.1, IC10.CS1, R28.1, SV2.6
unnamed: D5.C, IC10.IRQB
PA0: IC10.PA0, SV1.3; also elsewhere on the board
PA1: IC10.PA1, SV1.5; also elsewhere on the board
PA2: IC10.PA2, SV1.7; also elsewhere on the board
PA3: IC10.PA3, SV1.9; also elsewhere on the board
PA4: IC10.PA4, SV1.11; also elsewhere on the board
PA5: IC10.PA5, SV1.13; also elsewhere on the board
PA6: IC10.PA6, SV1.15; also elsewhere on the board
PA7: IC10.PA7, SV1.17; also elsewhere on the board
PB0: IC10.PB0; also elsewhere on the board
PB1: IC10.PB1; also elsewhere on the board
PB2: IC10.PB2; also elsewhere on the board
PB3: IC10.PB3; also elsewhere on the board
PB4: IC10.PB4, SV1.1
PB6: IC10.PB6; also elsewhere on the board
PB7: IC10.PB7; also elsewhere on the board
PHI0: IC11.37 (O0); also elsewhere on the board
PHI1: IC11.3 (O1); also elsewhere on the board
PHI2: IC10.PHI2, IC11.39 (O2), SV2.3; also elsewhere on the board
R/!W: IC10.RWB, IC11.34 (R/#W), SV2.7; also elsewhere on the board

Notes on the sheet:
Strobe
Ack
Decoupling

Parts:
C10, C11, C12, C13: 100nF; C050-025X075
IC12: ICM7555; DIL08
R31, R32: 1M; 0207/2V
R33, R34: 2K2; 0207/10
T1: 2N3904; TO92

Connections:
!RESET: R33.1, T1.1 (C); also elsewhere on the board
+5V: C13.1, IC12.4 (RESET), IC12.8 (V+), R31.2, R32.2, R33.2; also elsewhere on the board
GND: C10.2, C11.2, C12.2, C13.2, IC12.1 (GND), T1.3 (E); also elsewhere on the board
unnamed: C10.1, IC12.6 (TRSH), IC12.7 (DISCH), R31.1
unnamed: C11.1, IC12.5 (CV)
unnamed: C12.1, IC12.2 (TRIG), R32.1
unnamed: R34.2, T1.2 (B)
unnamed: IC12.3 (OUT), R34.1

Notes on the sheet:
Decoupling

Parts:
C25: 100uF 25V 105C; E2,5-7
C26: 100nF; C050-025X075
IC13: 7805 or equivalent; TO220H
U$2: 2.1MMJACKTHM; PJ-102A

Connections:
+5V: C26.1, IC13.3 (VO); also elsewhere on the board
GND: C25.-, C26.2, IC13.2 (GND), U$2.RING, U$2.RING_SW; also elsewhere on the board
unnamed: C25.+, IC13.1 (VI), U$2.TIP

Notes on the sheet:
It is strongly reccomended that a switching equivalent is used. Board space to provide room for either including heatsink space.

Board: 2 copper layers, 206.5 x 138.0 mm, 94 parts (1 on the bottom side), 138 nets.

Other parts of the board:
U$3: ORICLONE-1

Notices in the files:
parts and their libraries:
SparkFun: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
