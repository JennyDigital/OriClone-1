# Repository JennyDigital/OriClone-1 (continued)

## EAGLE design project/Oric Tactile KB/Oric Tactile KB 1.2b.brd

Parts:
IC1: 4051N; DIL16
JP1: PINHD-1X14; 1X14
LED1: P-LED; LED3MM
R1: 1K2; 0207/7

Connections:
+5V: IC1.16 (VCC), JP1.14, R1.2
COL_0: JP1.1; also elsewhere on the board
COL_1: JP1.2; also elsewhere on the board
COL_2: JP1.3; also elsewhere on the board
COL_3: JP1.4; also elsewhere on the board
COL_4: JP1.12; also elsewhere on the board
COL_5: JP1.11; also elsewhere on the board
COL_6: JP1.9; also elsewhere on the board
COL_7: JP1.5; also elsewhere on the board
GND: IC1.6 (INH), IC1.7 (VEE), IC1.8 (GND), JP1.10, LED1.K (C)
KB_INT: IC1.3 (X), JP1.13
unnamed: LED1.A, R1.1
ROW_0: IC1.13 (X0); also elsewhere on the board
ROW_1: IC1.14 (X1); also elsewhere on the board
ROW_2: IC1.15 (X2); also elsewhere on the board
ROW_3: IC1.12 (X3); also elsewhere on the board
ROW_4: IC1.1 (X4); also elsewhere on the board
ROW_5: IC1.5 (X5); also elsewhere on the board
ROW_6: IC1.2 (X6); also elsewhere on the board
ROW_7: IC1.4 (X7); also elsewhere on the board
ROW_A0: IC1.11 (A), JP1.8
ROW_A1: IC1.10 (B), JP1.7
ROW_A2: IC1.9 (C), JP1.6

Parts:
1_PLING, 2_@, 3_#, 4_$, 5_%, 6_^, 7_&, 8_*, 9_(, ._>: CHERRY-MX
'_": CHERRY-MX
,_<: CHERRY-MX
-_£: CHERRY-MX
/_?: CHERRY-MX
=_+: CHERRY-MX
A: CHERRY-MX
B: CHERRY-MX
BS_PIPE: CHERRY-MX
C: CHERRY-MX
CTRL: CHERRY-MX
D: CHERRY-MX
DEL: CHERRY-MX
DOWN_ARR: CHERRY-MX
E: CHERRY-MX
ESC: CHERRY-MX
F: CHERRY-MX
FUNC: CHERRY-MX
G: CHERRY-MX
H: CHERRY-MX
I: CHERRY-MX
J: CHERRY-MX
K: CHERRY-MX
L: CHERRY-MX
LEFT_ARR: CHERRY-MX
LEFT_SH: CHERRY-MX
M: CHERRY-MX
N: CHERRY-MX
O: CHERRY-MX
P: CHERRY-MX
Q: CHERRY-MX
R: CHERRY-MX
RETURN: CHERRY-MX
RHT_SH: CHERRY-MX
RIGHT_ARR: CHERRY-MX
S: CHERRY-MX
SCLN_CLN: CHERRY-MX
SPACE: CHERRY-MX
T: CHERRY-MX
U: CHERRY-MX
UP_ARR: CHERRY-MX
V: CHERRY-MX
W: CHERRY-MX
X: CHERRY-MX
Y: CHERRY-MX
Z: CHERRY-MX
ZERO_): CHERRY-MX
[_{: CHERRY-MX
]_}: CHERRY-MX

Connections:
COL_0: 7_&.SW1 (PIN-1), 8_*.SW1 (PIN-1), J.SW1 (PIN-1), K.SW1 (PIN-1), M.SW1 (PIN-1), SPACE.SW1 (PIN-1), U.SW1 (PIN-1), Y.SW1 (PIN-1); also elsewhere on the board
COL_1: 6_^.SW1 (PIN-1), 9_(.SW1 (PIN-1), ,_<.SW1 (PIN-1), H.SW1 (PIN-1), I.SW1 (PIN-1), L.SW1 (PIN-1), N.SW1 (PIN-1), T.SW1 (PIN-1); also elsewhere on the board
COL_2: 5_%.SW1 (PIN-1), ._>.SW1 (PIN-1), B.SW1 (PIN-1), G.SW1 (PIN-1), O.SW1 (PIN-1), R.SW1 (PIN-1), SCLN_CLN.SW1 (PIN-1), ZERO_).SW1 (PIN-1); also elsewhere on the board
COL_3: 4_$.SW1 (PIN-1), -_£.SW1 (PIN-1), /_?.SW1 (PIN-1), E.SW1 (PIN-1), F.SW1 (PIN-1), P.SW1 (PIN-1), UP_ARR.SW1 (PIN-1), V.SW1 (PIN-1); also elsewhere on the board
COL_4: CTRL.SW1 (PIN-1), FUNC.SW1 (PIN-1), LEFT_SH.SW1 (PIN-1), RHT_SH.SW1 (PIN-1); also elsewhere on the board
COL_5: 1_PLING.SW1 (PIN-1), A.SW1 (PIN-1), DEL.SW1 (PIN-1), ESC.SW1 (PIN-1), LEFT_ARR.SW1 (PIN-1), RETURN.SW1 (PIN-1), Z.SW1 (PIN-1); also elsewhere on the board
COL_6: 2_@.SW1 (PIN-1), BS_PIPE.SW1 (PIN-1), DOWN_ARR.SW1 (PIN-1), Q.SW1 (PIN-1), S.SW1 (PIN-1), X.SW1 (PIN-1), ]_}.SW1 (PIN-1); also elsewhere on the board
COL_7: 3_#.SW1 (PIN-1), '_".SW1 (PIN-1), =_+.SW1 (PIN-1), C.SW1 (PIN-1), D.SW1 (PIN-1), RIGHT_ARR.SW1 (PIN-1), W.SW1 (PIN-1), [_{.SW1 (PIN-1); also elsewhere on the board
ROW_0: 1_PLING.SW2 (PIN-2), 3_#.SW2 (PIN-2), 5_%.SW2 (PIN-2), 7_&.SW2 (PIN-2), N.SW2 (PIN-2), V.SW2 (PIN-2), X.SW2 (PIN-2); also elsewhere on the board
ROW_1: D.SW2 (PIN-2), ESC.SW2 (PIN-2), F.SW2 (PIN-2), J.SW2 (PIN-2), Q.SW2 (PIN-2), R.SW2 (PIN-2), T.SW2 (PIN-2); also elsewhere on the board
ROW_2: 2_@.SW2 (PIN-2), 4_$.SW2 (PIN-2), 6_^.SW2 (PIN-2), B.SW2 (PIN-2), C.SW2 (PIN-2), CTRL.SW2 (PIN-2), M.SW2 (PIN-2), Z.SW2 (PIN-2); also elsewhere on the board
ROW_3: 9_(.SW2 (PIN-2), '_".SW2 (PIN-2), -_£.SW2 (PIN-2), BS_PIPE.SW2 (PIN-2), K.SW2 (PIN-2), SCLN_CLN.SW2 (PIN-2); also elsewhere on the board
ROW_4: ,_<.SW2 (PIN-2), ._>.SW2 (PIN-2), DOWN_ARR.SW2 (PIN-2), LEFT_ARR.SW2 (PIN-2), LEFT_SH.SW2 (PIN-2), RIGHT_ARR.SW2 (PIN-2), SPACE.SW2 (PIN-2), UP_ARR.SW2 (PIN-2); also elsewhere on the board
ROW_5: DEL.SW2 (PIN-2), FUNC.SW2 (PIN-2), I.SW2 (PIN-2), O.SW2 (PIN-2), P.SW2 (PIN-2), U.SW2 (PIN-2), [_{.SW2 (PIN-2), ]_}.SW2 (PIN-2); also elsewhere on the board
ROW_6: A.SW2 (PIN-2), E.SW2 (PIN-2), G.SW2 (PIN-2), H.SW2 (PIN-2), S.SW2 (PIN-2), W.SW2 (PIN-2), Y.SW2 (PIN-2); also elsewhere on the board
ROW_7: 8_*.SW2 (PIN-2), /_?.SW2 (PIN-2), =_+.SW2 (PIN-2), L.SW2 (PIN-2), RETURN.SW2 (PIN-2), RHT_SH.SW2 (PIN-2), ZERO_).SW2 (PIN-2); also elsewhere on the board

Board: 2 copper layers, 273.1 x 146.1 mm, 63 parts (1 on the bottom side), 23 nets.

Other parts of the board:
U$1: ORICLONE-1

## Commit log

2020-01-11 Initial Commit.
2021-12-30 Added amended board and new keyboard design. Also included is pre-done gerbers and excellon drill files.
2022-02-10 Cumulative fixes for mistakes to earlier version
2022-02-10 Update README.md
    Added note to inform the user of possible tape port issue.
2023-05-17 Update README.md
    I changed my name and now this reflects that fact.
2023-05-25 Add dual ROM image for the OriClone-1 to boot to.
    You can choose to boot up as either an Oric-1 or an Atmos with this new addition.
2023-11-11 The OriClone-1 has had a little cosmetic!
    Also, the keyboard spacebar positioning has been fixed, and there's a new keyboard variant that centers the OriClone-1 PCB.
2023-11-11 No idea why, but some of the project files went missing! So here they are...
2023-11-25 Update OriClone-1.pdf, OriClone-1 v2.3.zip, OriClone-1 v2.31.zip, and 44 more files
2023-12-09 Updated the board artwork for the OriClone 1 to v2.32, also added a slimmer keyboard layout that is easier to mount.
2023-12-27 Updated library part.
2024-01-06 Added pinouts for the benefit of debugging etc.
